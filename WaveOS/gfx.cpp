// WAVE OS - pixel-art drawing helpers (240x135, built-in 5x7 GLCD font)
#include "common.h"
#ifdef CLIP_LOG
bool clipQuiet = false;  // set while drawing scrolling menus (cards slide off-screen on purpose)
#endif
#include "audio.h"
#include <Preferences.h>

Theme T;
static M5Canvas bgs(&M5Cardputer.Display);
static bool bgReady = false;

static uint16_t hexc(const String& h) {
  long v = strtol(h.c_str(), nullptr, 16);
  return RGB((v >> 16) & 255, (v >> 8) & 255, v & 255);
}
bool customThemeExists() { return sdOK && SD.exists("/themes/custom.txt"); }
void applyTheme(int theme) {
  if (theme == 1) {
    T = {RGB(6, 6, 6), RGB(14, 14, 14), RGB(24, 24, 24), RGB(16, 16, 16), RGB(64, 64, 64),
         RGB(240, 240, 240), RGB(70, 70, 70), RGB(200, 200, 200), RGB(50, 50, 50), RGB(160, 160, 160),
         RGB(40, 40, 40), RGB(220, 220, 220), RGB(250, 250, 250), RGB(130, 130, 130), RGB(60, 60, 60),
         RGB(225, 225, 225), RGB(255, 255, 255), RGB(200, 200, 200), RGB(10, 10, 10)};
  } else {
    T = {RGB(4, 7, 14), RGB(8, 14, 26), RGB(14, 22, 40), RGB(12, 20, 36), RGB(30, 48, 80),
         RGB(62, 232, 240), RGB(16, 70, 90), RGB(74, 140, 255), RGB(20, 40, 90), RGB(154, 92, 255),
         RGB(44, 24, 84), RGB(255, 92, 190), RGB(232, 240, 255), RGB(110, 124, 150), RGB(52, 62, 84),
         RGB(90, 240, 150), RGB(255, 210, 90), RGB(255, 80, 100), RGB(6, 10, 20)};
    if (theme == 2 && customThemeExists()) {  // /themes/custom.txt  key=RRGGBB
      File f = SD.open("/themes/custom.txt");
      while (f && f.available()) {
        String l = f.readStringUntil('\n'); l.trim();
        int e = l.indexOf('=');
        if (e < 0 || l.startsWith("#")) continue;
        String k = l.substring(0, e); k.trim(); k.toLowerCase();
        uint16_t c = hexc(l.substring(e + 1));
        if (k == "bg0") T.bg0 = c; else if (k == "bg1") T.bg1 = c; else if (k == "bg2") T.bg2 = c;
        else if (k == "panel") T.panel = c; else if (k == "edge") T.edge = c; else if (k == "cyan") T.cyan = c;
        else if (k == "blue") T.blue = c; else if (k == "purple") T.purp = c; else if (k == "pink") T.pink = c;
        else if (k == "white") T.white = c; else if (k == "grey") T.grey = c; else if (k == "dim") T.dim = c;
        else if (k == "green") T.green = c; else if (k == "yellow") T.yel = c; else if (k == "red") T.red = c;
        else if (k == "bar") T.bar = c;
      }
      if (f) f.close();
      T.cyanD = lerpc(T.bg0, T.cyan, 0.3f); T.blueD = lerpc(T.bg0, T.blue, 0.3f); T.purpD = lerpc(T.bg0, T.purp, 0.3f);
    }
  }
  rebuildBackground();
}

uint16_t lerpc(uint16_t a, uint16_t b, float t) {
  if (t <= 0) return a;
  if (t >= 1) return b;
  int r1 = (a >> 11) & 31, g1 = (a >> 5) & 63, b1 = a & 31;
  int r2 = (b >> 11) & 31, g2 = (b >> 5) & 63, b2 = b & 31;
  int r = r1 + (r2 - r1) * t, g = g1 + (g2 - g1) * t, bb = b1 + (b2 - b1) * t;
  return (r << 11) | (g << 5) | bb;
}
uint16_t gradc(float t) {
  t = constrain(t, 0.f, 1.f);
  return t < 0.5f ? lerpc(T.cyan, T.blue, t * 2) : lerpc(T.blue, T.purp, (t - 0.5f) * 2);
}

// ------------------------------------------------------------------ text
int textW(const char* s, int sc) { return (int)strlen(s) * 6 * sc - sc; }
int text(int x, int y, const char* s, uint16_t c, int sc, bool sh) {
  cv.setFont(&fonts::Font0);
  cv.setTextSize(sc);
  cv.setTextDatum(top_left);
  if (sh) { cv.setTextColor(T.bg0); cv.drawString(s, x + 1, y + 1); }
  cv.setTextColor(c);
  cv.drawString(s, x, y);
#ifdef CLIP_LOG
  extern bool clipQuiet;
  if (!clipQuiet && (x < 0 || x + textW(s, sc) > 240)) {  // dev: log text that runs off the screen (once per string)
    static uint32_t seen[256]; static int ns = 0;
    uint32_t h = 2166136261u; for (const char* p = s; *p; p++) h = (h ^ (uint8_t)*p) * 16777619u;
    bool dup = false; for (int i = 0; i < ns; i++) dup |= seen[i] == h;
    if (!dup) { if (ns < 256) seen[ns++] = h; Serial.printf("[clip] x=%d w=%d '%s'\n", x, textW(s, sc), s); }
  }
#endif
  return x + textW(s, sc) + sc;
}
void textC(int cx, int y, const char* s, uint16_t c, int sc, bool sh) { text(cx - textW(s, sc) / 2, y, s, c, sc, sh); }
void textFit(int x, int y, const char* s, uint16_t c, int maxw, bool sh) {
  int maxc = (maxw + 1) / 6;
  if ((int)strlen(s) <= maxc) { text(x, y, s, c, 1, sh); return; }
  char buf[64];
  int n = std::min(maxc - 2, 60);
  if (n < 1) n = 1;
  memcpy(buf, s, n);
  buf[n] = '.'; buf[n + 1] = '.'; buf[n + 2] = 0;
  text(x, y, buf, c, 1, sh);
}

// ------------------------------------------------------------------ shapes
void frame(int x, int y, int w, int h, uint16_t c) {
  cv.drawFastHLine(x + 1, y, w - 2, c);
  cv.drawFastHLine(x + 1, y + h - 1, w - 2, c);
  cv.drawFastVLine(x, y + 1, h - 2, c);
  cv.drawFastVLine(x + w - 1, y + 1, h - 2, c);
}
void panel(int x, int y, int w, int h, uint16_t edge, uint16_t fill) {
  cv.fillRect(x + 1, y + 1, w - 2, h - 2, fill);
  frame(x, y, w, h, edge);
  cv.drawFastHLine(x + 2, y + 1, w - 4, lerpc(fill, T.white, 0.07f));  // top bevel
}
void panel(int x, int y, int w, int h, uint16_t edge) { panel(x, y, w, h, edge, T.panel); }
void glowFrame(int x, int y, int w, int h, uint16_t c) {
  frame(x - 1, y - 1, w + 2, h + 2, lerpc(T.bg0, c, 0.35f));
  frame(x, y, w, h, c);
}

// ------------------------------------------------------------------ background (dithered vignette + stars)
static const uint8_t BAYER[4][4] = {{0, 8, 2, 10}, {12, 4, 14, 6}, {3, 11, 1, 9}, {15, 7, 13, 5}};
static void palC(int i, uint16_t c) { bgs.setPaletteColor(i, ((c >> 11) & 31) * 255 / 31, ((c >> 5) & 63) * 255 / 63, (c & 31) * 255 / 31); }
// fast copy: the 2-bit sprite is expanded with a 256-entry table (4 pixels per byte) straight into the
// frame buffer. pushSprite() converted pixel by pixel and took ~12ms of every frame.
static uint64_t bgLut[256];
int bgFast = 0;  // 0 untested, 1 fast path verified, -1 use pushSprite
static void bgBuildLut() {
  uint16_t pc[4];
  const uint16_t cols[4] = {T.bg0, T.bg1, T.bg2, lerpc(T.dim, T.grey, 0.5f)};
  for (int i = 0; i < 4; i++) { uint16_t c = cols[i]; pc[i] = (uint16_t)((c >> 8) | (c << 8)); }  // frame buffer is byte swapped
  for (int v = 0; v < 256; v++) {
    uint64_t q = 0;
    for (int k = 0; k < 4; k++) q |= (uint64_t)pc[(v >> (6 - 2 * k)) & 3] << (16 * k);
    bgLut[v] = q;
  }
}
static bool bgCopyFast() {
  const uint8_t* src = (const uint8_t*)bgs.getBuffer();
  uint64_t* dst = (uint64_t*)cv.getBuffer();
  if (!src || !dst || cv.width() != 240 || cv.height() != 135) return false;
  for (int i = 0; i < 240 * 135 / 4; i++) dst[i] = bgLut[src[i]];
  return true;
}
void rebuildBackground() {
  if (!bgReady) {  // 2-bit palette sprite: 8KB instead of 64KB
    bgs.setColorDepth(2);
    bgReady = bgs.createSprite(240, 135) != nullptr;
    if (!bgReady) return;
    bgs.createPalette();
  }
  palC(0, T.bg0); palC(1, T.bg1); palC(2, T.bg2); palC(3, lerpc(T.dim, T.grey, 0.5f));
  bgBuildLut(); if (bgFast > 0) bgFast = 0;  // theme changed: re-verify
  for (int y = 0; y < 135; y++)
    for (int x = 0; x < 240; x++) {
      float dx = (x - 144) / 240.f, dy = (y - 74) / 135.f;
      float t = std::max(0.f, 1 - sqrtf(dx * dx + dy * dy) * 1.6f) * 2.2f;
      int l = (int)t;
      float fr = t - l;
      int idx = std::min(l + (fr * 16 > BAYER[y & 3][x & 3] ? 1 : 0), 2);
      bgs.drawPixel(x, y, idx);
    }
  uint32_t r = 7;
  for (int i = 0; i < 55; i++) {
    r = r * 1103515245 + 12345; int x = (r >> 8) % 240;
    r = r * 1103515245 + 12345; int y = (r >> 8) % 135;
    r = r * 1103515245 + 12345;
    bgs.drawPixel(x, y, 3);
  }
}
void background(bool plain) {
  if (plain || !bgReady) { cv.fillSprite(T.bg0); return; }
  if (bgFast == 0) {  // first use: check the table gives exactly what pushSprite draws
    bgs.pushSprite(&cv, 0, 0);
    const uint8_t* src = (const uint8_t*)bgs.getBuffer();
    const uint64_t* dst = (const uint64_t*)cv.getBuffer();
    bgFast = -1;
    if (src && dst) {
      bgFast = 1;
      for (int i = 0; i < 240 * 135 / 4; i++) if (dst[i] != bgLut[src[i]]) { bgFast = -1; break; }
    }
    Serial.printf("[gfx] fast background %s\n", bgFast > 0 ? "ok" : "MISMATCH, using pushSprite");
    return;
  }
  if (bgFast < 0 || !bgCopyFast()) bgs.pushSprite(&cv, 0, 0);
}

void drawWave(int x0, int x1, int cy, float amp, float phase, bool glow, float reveal) {
  int xe = x0 + (int)((x1 - x0) * reveal);
  auto yf = [&](int x, float& f1, float& f2) {
    float t = (x - x0) / (float)(x1 - x0);
    f1 = cy - amp * sinf(2 * PI * (t * 0.8f) - 2.2f + phase);
    f2 = f1 + amp * 0.32f * powf(sinf(PI * t), 1.4f);
  };
  // pass 1: soft halo, tapered to nothing at both ends and at the drawing edge
  if (glow) {
    for (int x = x0; x <= xe; x++) {
      float f1, f2; yf(x, f1, f2);
      float t = (x - x0) / (float)(x1 - x0);
      float taper = std::min(1.f, std::min(std::min((x - x0) / 14.f, (x1 - x) / 14.f), (xe - x) / 10.f));
      if (taper <= 0) continue;
      uint16_t c = gradc(t * 0.8f);
      int top = (int)lroundf(f1), bot = (int)lroundf(f2);
      int rmax = std::max(1, (int)lroundf(3 * taper));
      for (int r = rmax; r >= 1; r--) {
        float al = (r == 3 ? 0.07f : r == 2 ? 0.14f : 0.26f) * taper;
        cv.drawFastVLine(x, top - r, bot - top + 1 + 2 * r, lerpc(T.bg0, c, al));
      }
    }
  }
  // pass 2: two crisp 1px strands; steps connect diagonally; purple stops where it merges into cyan
  int p1 = INT32_MIN, p2 = INT32_MIN;
  for (int x = x0; x <= xe; x++) {
    float f1, f2; yf(x, f1, f2);
    float t = (x - x0) / (float)(x1 - x0);
    int y1 = (int)lroundf(f1), y2 = (int)lroundf(f2);
    uint16_t c1 = gradc(t * 0.7f), c2 = lerpc(gradc(t), T.purp, 0.6f);
    bool split = f2 - f1 >= 1.5f;
    if (split) {
      if (p2 == INT32_MIN || abs(p2 - y2) <= 1) cv.drawPixel(x, y2, c2);
      else cv.drawFastVLine(x, std::min(p2, y2) + (p2 < y2 ? 1 : 0), abs(p2 - y2), c2);
      p2 = y2;
    } else p2 = INT32_MIN;
    if (p1 == INT32_MIN || abs(p1 - y1) <= 1) cv.drawPixel(x, y1, c1);
    else cv.drawFastVLine(x, std::min(p1, y1) + (p1 < y1 ? 1 : 0), abs(p1 - y1), c1);
    p1 = y1;
  }
}


// ------------------------------------------------------------------ battery (smoothed voltage + Li-ion curve)
namespace Batt {
// The ADV has no fuel gauge, only a battery-voltage ADC. On USB the charger holds that voltage near
// 4.2V, so it says nothing about the real charge. Strategy:
//  - on battery: % from a smoothed, load-compensated voltage curve (only allowed to go down)
//  - on USB: start from the last real on-battery %, count up at a realistic charge rate
//  - the last real % is kept in flash (NVS) so restarts / power-off don't lose it
//  - mismatches are corrected by gliding, never jumping
float mv = 0;
int pct = -1;
bool usb = false, charging = false;
static float shown = -1;
static uint32_t t = 0, usbSince = 0, highSince = 0;
static bool lastUsb = false, inited = false;
static int savedPct = -1;
static Preferences prefs;
static float curve(float v) {  // 1S Li-ion resting voltage -> %
  static const float V[] = {3300, 3450, 3550, 3620, 3680, 3730, 3770, 3810, 3860, 3930, 4010, 4100, 4180};
  static const float P[] = {0, 3, 7, 12, 20, 30, 40, 50, 60, 70, 80, 90, 100};
  if (v <= V[0]) return 0;
  for (int i = 1; i < 13; i++)
    if (v < V[i]) return P[i - 1] + (v - V[i - 1]) * (P[i] - P[i - 1]) / (V[i] - V[i - 1]);
  return 100;
}
static void persist() {
  int p = (int)(shown + 0.5f);
  if (p != savedPct) { prefs.putInt("pct", p); savedPct = p; }
}
void tick() {
  uint32_t now = millis();
  if (inited && now - t < 1000) return;
  float dt = inited ? (now - t) / 1000.f : 0;
  t = now;
  int sum = 0, n = 0;
  for (int i = 0; i < 8; i++) { int v = M5.Power.getBatteryVoltage(); if (v > 2500 && v < 5000) { sum += v; n++; } }
  if (!n) return;
  float v = sum / (float)n;
  mv = mv <= 0 ? v : mv * 0.9f + v * 0.1f;
  usb = Serial.isPlugged();
  float onBatt = curve(mv + 35.f);  // +35mV: screen/CPU/audio load sag
  if (!inited) {
    inited = true;
    prefs.begin("batt", false);
    savedPct = prefs.getInt("pct", -1);
    if (!usb) shown = onBatt;                                       // real reading available
    else shown = savedPct >= 0 ? savedPct : std::min(onBatt, 60.f);  // plugged at boot: trust history
    lastUsb = usb; usbSince = now;
  }
  if (usb != lastUsb) { usbSince = now; lastUsb = usb; }
  bool settling = now - usbSince < 30000;
  if (usb) {
    // high voltage for a long time = constant-voltage phase finished -> full
    if (mv >= 4150) { if (!highSince) highSince = now; } else highSince = 0;
    bool full = highSince && now - highSince > 45UL * 60000UL;
    charging = !full;
    if (full) shown = std::min(100.f, shown + 0.1f * dt);
    else shown = std::min(99.f, shown + (0.55f / 60.f) * dt);  // ~0.55%/min (1750mAh at ~0.5A)
  } else {
    charging = false; highSince = 0;
    if (!settling) {
      if (onBatt < shown) shown = std::max(onBatt, shown - (shown - onBatt > 8 ? 0.12f : 0.04f) * dt);  // glide down
      else if (onBatt > shown + 6) shown = std::min(onBatt, shown + 0.04f * dt);                       // big under-estimate: glide up
    }
  }
  shown = constrain(shown, 0.f, 100.f);
  pct = (int)(shown + 0.5f);
  if (!usb && !settling) persist();  // only real (battery) values are remembered
  else if (usb && now % 60000 < 1100) persist();
}
}  // namespace Batt

// ------------------------------------------------------------------ status + hint bars
static int battCache = -1;
static uint32_t battT = 0;
void statusBar(const char* title, uint16_t accent) {
  cv.fillRect(0, 0, 240, 11, T.bar);
  bool mus = Music::active();
  float prog = mus && Music::len() > 0 ? Music::pos() / Music::len() : 0;
  for (int x = 0; x < 240; x++) {
    uint16_t base = lerpc(T.cyanD, T.purpD, x / 240.f);
    cv.drawPixel(x, 11, (mus && x < prog * 240) ? gradc(x / 240.f) : base);
  }
  {
    char pb[8]; snprintf(pb, sizeof(pb), "%d%%", constrain(Batt::pct, 0, 100));
    int lim = 218 - 10 - textW(pb) - 22 - (mus && !Music::paused() ? 14 : 4) - 4;
    textFit(4, 2, title, accent, lim);
  }
  String clk = clockString();
  if (clk.length() && textW(title) < 100) text(118, 2, clk.c_str(), T.white, 1, false);
  Batt::tick();
  battCache = Batt::pct;
  int bx = 218;
  frame(bx, 2, 17, 8, T.grey);
  cv.fillRect(bx + 17, 4, 1, 4, T.grey);
  int bl = constrain(battCache, 0, 100);
  uint16_t bc = bl > 50 ? T.green : (bl > 20 ? T.yel : T.red);
  if (bl <= 10 && !Batt::usb && (millis() / 500) % 2) bc = T.bar;  // blink when low
  cv.fillRect(bx + 2, 4, std::max(1, (13 * bl) / 100), 4, bc);
  if (Batt::usb) {  // plugged in: lightning bolt
    static const char* bolt[7] = {"..##", ".##.", "####", ".##.", "##..", "#...", "...."};
    for (int j = 0; j < 7; j++) for (int i = 0; i < 4; i++) if (bolt[j][i] == '#') cv.drawPixel(bx + 7 + i, 2 + j, j < 3 ? T.yel : T.white);
  }
  char b[8];
  snprintf(b, sizeof(b), "%d%%", bl);
  text(bx - 4 - textW(b), 2, b, T.grey, 1, false);
  int x = bx - 10 - textW(b);
  // speaker glyph + volume
  static const uint8_t spk[7] = {0b0010, 0b0110, 0b1110, 0b1110, 0b0110, 0b0010, 0};
  int vx = x - 22;
  for (int j = 0; j < 7; j++)
    for (int i = 0; i < 4; i++)
      if (spk[j] & (8 >> i)) cv.drawPixel(vx + i, 2 + j, T.grey);
  if (cfg.mute) { cv.drawLine(vx + 6, 2, vx + 13, 9, T.red); cv.drawLine(vx + 13, 2, vx + 6, 9, T.red); }
  else for (int i = 0; i < 4; i++) {
    int h = 2 + i;
    cv.fillRect(vx + 6 + i * 3, 9 - h, 2, h, (cfg.volume > i * 64) ? T.cyan : T.dim);
  }
  // now playing note
  if (mus && !Music::paused()) {
    int nx = vx - 12;
    uint16_t c = T.cyan;
    cv.drawFastVLine(nx + 3, 2, 6, c); cv.drawFastVLine(nx + 7, 1, 6, c);
    cv.drawFastHLine(nx + 3, 1, 5, c); cv.drawFastHLine(nx + 3, 2, 5, c);
    cv.fillRect(nx + 1, 7, 3, 2, c); cv.fillRect(nx + 5, 6, 3, 2, c);
  }
}
void hintBar(std::initializer_list<Hint> h) {
  cv.fillRect(0, 125, 240, 10, T.bar);
  // squeeze the spacing when the hints would not fit (keys, then gaps get tighter)
  int pad = 4, kg = 3, gap = 5;
  for (int pass = 0; pass < 4; pass++) {
    int w = 3;
    for (auto& it : h) w += (it.k && *it.k ? textW(it.k) + pad + kg : 0) + textW(it.l) + 1 + gap;
    if (w - gap <= 238) break;
    if (pass == 0) { kg = 2; gap = 3; } else if (pass == 1) { kg = 1; gap = 2; } else { pad = 2; }
  }
  int x = 3;
  for (auto& it : h) {
    if (x > 230) break;
    if (it.k && *it.k) {
      int w = textW(it.k) + pad;
      cv.fillRect(x, 126, w, 9, T.edge);
      text(x + pad / 2, 127, it.k, T.white, 1, false);
      x += w + kg;
    }
    x = text(x, 127, it.l, T.grey, 1, false) + gap;
  }
}

// ------------------------------------------------------------------ icons (16x16)
static const char* const ICONS[IC_COUNT][16] = {
 {"................","........######..","......########..","......##....##..","......##....##..","......##....##..","......##....##..","......##....##..","......##....##..","...####...####..","..#####..#####..","..#####..#####..","...###....###...","................","................","................"},
 {"................","................","################","#.#.##.#.#.##.##","#.#.##.#.#.##.##","#.#.##.#.#.##.##","#.#.##.#.#.##.##","#.#.##.#.#.##.##","#.#.##.#.#.##.##","#.##.##.##.##.##","#.##.##.##.##.##","#.##.##.##.##.##","#.##.##.##.##.##","################","................","................"},
 {"................",".....######.....","...##......##...","..#..........#..",".#...#....#...#.",".#............#.","#..#........#..#","#..............#","#......##......#",".#.....##.....#.",".#............#.","..#....##....#..","...##..##..##...",".....######.....","................","................"},
 {"..........#.....","........#..#....",".........#..#...","......#...#..#..","..#####...#..#..",".#.....#........",".#.##..#........",".#.##..#........",".#.....#........",".#.#.#.#........",".#.....#........",".#.#.#.#........",".#.....#........",".#.#.#.#........","..#####.........","................"},  // IR
 {"................",".##..........##.","#..#........###.","#...#......###..",".#..##....###...","..####...###....","....###.###.....",".....#####......","......###.......",".....#####......","....###..##.....","...###....##....","..###......##...",".###........##..",".##..........##.","................"},  // TOOLS
 {"................","..##########....","..#........##...","..#.######.#.#..","..#........####.","..#.#######...#.","..#...........#.","..#.#######...#.","..#...........#.","..#.#####.....#.","..#...........#.","..#.########..#.","..#...........#.","..#############.","................","................"},
 {"................","................","................","...##########...","..#..........#..",".#..#......#..#.",".#.###....#.#.#.",".#..#......#..#.",".#.........#..#.",".#..........#.#.","..#...####...#..","...###....###...","................","................","................","................"},
 {"................",".......##.......","...#..####..#...","..###.#..#.###..","...##########...","...##......##...","####..####..####","##...##..##...##","##...##..##...##","####..####..####","...##......##...","...##########...","..###.#..#.###..","...#..####..#...",".......##.......","................"},
 {"................","..############..","..#..........#..","..#.########.#..","..#.#......#.#..","..#.########.#..","..#..........#..","..#.##.##.##.#..","..#.##.##.##.#..","..#..........#..","..#.##.##.##.#..","..#.##.##.##.#..","..#..........#..","..############..","................","................"},
 {"................",".#..............",".#...........##.",".#..........#...",".#.........#....",".#...##....#....",".#..#..#..#.....",".#.#....##......",".##.............",".#..............",".#..............",".#..............",".##############.","................","................","................"},
 {"................","................","................","................","................","....########....","...#.#.#..#.#...","####.#.#..#.####","...#.#.#..#.#...","....########....","................","................","................","................","................","................"},
 {"................","................","..######........","..#....#........","..#.##.#........","..#.##.######...","..#.........#...","..######....#...",".......#....#...",".......#.####.#.",".......#.#......",".......###......","................","................","................","................"},
 {"................",".######.######..",".#....#.#....#..",".#.##.#.#.##.#..",".#....#.#....#..",".######.######..","................",".######.######..",".#....#.######..",".#.##.#.######..",".#....#.######..",".######.######..","................","................","................","................"},
 {"............##..","...........##...","..........##....",".........##.....","........##......","....###.#.......","...#####........","..######........",".#######........",".####.##........",".###..##........","..####..........","...##...........","................","................","................"},
 {"................","......##........",".....##.........","....##..........","...######.......","......##........",".....##.........","....##..........","...##...........","................","..#..#..#..#....","################","..#..#..#..#....","................","................","................"},
 {"......##........","......##........","....######......","....######......","................","................","##............##","##............##","####......######","####......######","######..########","######..########","################","################","................","................"},  // BLOCKS
 {"................","################","#.##.##.##.##.##","################","#.##.##.##.##.##","................","................","................","........##......","................","................","................","................",".....######.....",".....######.....","................"},
 {"................","................","......####......",".....######.....","....###.#.##....","....########....","...#####........","..#######.......","..######........","...####.........","................","..#........#....","..#........#....","..##......##....","................","................"},
 {"................","................","################","#..............#","#.##.##.##.##..#","#..............#","#.##.##.##.##..#","#..............#","#..##.######.#.#","#..............#","################","................","................","................","................","................"},
 {"................",".##...##...##...",".##...##...##...","................",".##.......##....",".##.......##....","................","......##........","......##........","................","################","................","..##..##..##..##","................","................","................"},
 {"................","....########....","..##........##..",".#............#.",".##..........##.",".#.##......##.#.",".#...######...#.",".#............#.",".#............#.",".#............#.",".##..........##.","..##........##..","....########....","................","##............##","..##........##.."},
 {".......##.......",".......##.......","......####......","......####......",".....######.....","..#..######..#..","..#.########.#..","..############..",".##############.",".###..####..###.",".##....##....##.","................","...#...##...#...","................",".......##.......","................"},
 {"................",".......##.......","..#....##....#..","...#.######.#...","....########....","...###..#####...","...##...#####...",".##############.",".##############.","...##########...","...##########...","....########....","...#.######.#...","..#....##....#..",".......##.......","................"},
 {"................","................",".##.............",".##.............",".##..........##.",".##..........##.",".##.....##...##.",".##.....##...##.",".##..........##.",".##..........##.",".##.............",".##.............","................","..#.#.#.#.#.#...","................","................"},  // DUEL
 {"................","..........#.....","......#....#....",".....##..#..#...","....###...#..#..","#######....#.#..","#######.#..#..#.","#######.#..#..#.","#######.#..#..#.","#######....#.#..","....###...#..#..",".....##..#..#...","......#....#....","..........#.....","................","................"},  // ECHO
 {"................","........###.....","........###.....",".........#......",".......####.....","......#.##.#....",".....#..##..#...","........##......",".......#..#.....","......#....#....",".....#......#...","................","################","................","................","................"},
 {"################","#..............#","#.######.#####.#","#.#......#...#.#","#.#.######.#.#.#","#.#.#......#.#.#","#...#.######.#.#","#####.#......#.#","#.....#.######.#","#.#####.#......#","#.#.....#.####.#","#.#.#####.#..#.#","#...#.....#.##.#","###.#.#####....#","#.....#.....##.#","################"},
 {"................","################","#.##.##.##.##..#","#.##.##.##.##..#","#..............#","#.##.##.##.##..#","#.##.##.##.##..#","#..............#","#.##.##.##.##..#","#.##.##.##.##..#","#..............#","################","#..............#","................","................","................"},
 {"................","................","..........#.....",".........#......","........#.......",".....####.......","....######......","..##########....",".############...","#.#.#.#.#.#.#...",".############...","................","################","################","................","................"},
 {"................","......#####.....","....##.....##...","...#..##.....#..","..#..#..#.....#.","..#...##...#..#.","..#.......#.#.#.","...#.......#..#.","....#........#..",".....########...","................","..#.............",".###............",".#.#............","##.##...........","................"},  // ROCKS
 {"................","...##.....##....","..#..#...#..#...","..#.##...##.#...","..#..#####..#...",".#...........#..","#.............#.","#..#########..#.","#.............#.",".#...........#..","..###########...",".##.#.....#.##..","##..#.....#..##.","................","................","................"},  // HOPPER
 {"......####......",".......##.......",".....######.....","...##......##...","..#....#.....#..",".#.....#......#.",".#.....#......#.","#......#.......#","#......####....#","#..............#",".#............#.",".#............#.","..#..........#..","...##......##...",".....######.....","................"},
 {"................","#######.........","#.....#.........","#.#...#.........","#..#..#.........","#...#.#.........","#.....#.#######.","#######.#.....#.","........#.#.#.#.","........#.....#.","........#.#.#.#.","........#.....#.","........#.#.#.#.","........#######.","................","................"},  // FUN
 {"################","#....#....#....#","#.#..#.##.#..#.#","#....#....#....#","################","#.##.#....#....#","#....#..#.#.##.#","#....#....#....#","################","#....#.#..#....#","#.#..#....#..#.#","#....#....#....#","################","................","................","................"},
 {"................","................","..###...........",".#...#..........",".#####..........",".#...#..........",".#...#..........","................","..........##....","..##..##..##....","................","................","################","................","................","................"},
 {"................","...#........#...","..##........##..","..############..",".##############.",".##..######..##.",".##..######..##.",".##############.",".######..######.",".#######..#####.",".##############.","..############..","...##......##...","................","................","................"},
 {"................","............##..","...........####.","..........####..",".........####...","........####....",".......####.....","......####......",".....####.......","....####........","...###..........","..##............","..#.............","................","#..#..#..#..#..#","................"},
 {"................","....#....#......","#.#.#....#.###..",".#..#....#.#.#..","#.#.#....#.###..","################","....#....#......","....#.##.#......","....#.##.#......","################","....#....#.#.#..","....#....#..#...","....#....#.#.#..","................","................","................"},
 {"................","..###.....###...",".#...#...#..##..",".#.#.#...#...#..",".#...#....###...","..###...........","........###.....",".......#...#....","..###..#.#.#....",".#.#.#.#...#....",".#...#..###.....","..###...........","................","................","................","................"},
 {"................",".....######.....","...##......##...","..#..........#..",".#.....##.....#.",".#....####....#.","#....##..##....#","#....##..##....#","#.....####.....#",".#.....##.....#.",".#............#.","..#..........#..","...##......##...",".....######.....","....########....","................"},
 {"................","....########....","..##........##..",".#....####....#.","#...##....##...#","...#........#...","..#...####...#..",".....#....#.....","....#......#....",".......##.......","......####......",".......##.......","................","................","................","................"},
 {"................","..############..","..#..........#..","..############..","...#........#...","....#......#....",".....######.....",".....#....#.....",".....#.##.#.....",".....#.##.#.....",".....#....#.....",".....#....#.....",".....######.....","................","................","................"},
 {"................","................","................","..###...........","..###...........","................","..###..#######..","..###..#######..","................","..#######..###..","..#######..###..","................","..###..###..###.","..###..###..###.","................","................"},
 {"................",".####.####.####.",".####.#..#.####.",".####.#..#.####.",".####.####.####.","................",".####.####.####.",".#..#.####.#..#.",".#..#.####.#..#.",".####.####.####.","................",".####.####.####.",".####.####.#..#.",".####.####.#..#.",".####.####.####.","................"},  // LIGHTS
 {"................",".####.####.####.",".##.#.#..#.#..#.",".#.##.#..#.#..#.",".####.####.####.","................",".####.####.####.",".#..#.##.#.#..#.",".#..#.#.##.#..#.",".####.####.####.","................",".####.####......",".#..#.#..#..#...",".#..#.#..#.####.",".####.####..#...","................"},  // SLIDE
 {"................","...........###..","..........###...",".........###....","........###.....",".......###......","......########..",".....########...","........###.....",".......###......","......###.......",".....###........","....##..........","...#............","................","................"},  // REFLEX
 {"................","................",".###.###.###.###",".###.###.###.###",".###.###.###.###","................","................",".###.###.###.###",".#.#.#.#.#.#.#.#",".###.###.###.###","................","................","..##..##........","..##..##..##..##","..........##..##","................"},  // CODE
 {"................","................",".##.......##....",".##.......##....",".##.##.##.##.##.","................","....##.##.......","....##.##.......",".##.##.##.##.##.","................",".##.##.##.##.##.",".##.##.##.##.##.",".##.##.##.##.##.","................","................","................"},  // FIVE
 {"................","................","......###.......","......###.......","......###.......","................","..........###...","..........###...","..........###...","................","..###.###.###...","..###.###.###...","..###.###.###...","................","................","................"},  // LIFE
 {"................","......####......","......#..#....##",".....#....#..##.",".....#....#.##..","....#......##...","....#.....###...","...#.....##..#..","...#....##...#..","..#....##.....#.","..#...###.....#.",".#....###......#",".###############",".###############","................","................"},  // METRO
 {"................","................","................","################","#..............#","#.....#..#.....#","#....######....#","#...########...#","#....######....#","#.....#..#.....#","#..............#","################","................","................","................","................"},  // LEVEL
 {"................","..........#.....","..........##....","###############.","###############.","..........##....","..........#.....","................","................",".....#..........","....##..........",".###############",".###############","....##..........",".....#..........","................"},  // CONV
 {".....######.....","...##..##..##...","..#....##....#..",".#.#...##...#.#.",".#..#..##..#..#.","#....#.##.#....#","#.....####.....#","################","################","#.....####.....#","#....#.##.#....#",".#..#..##..#..#.",".#.#...##...#.#.","..#....##....#..","...##..##..##...",".....######....."}  // DECIDE
};
void drawIcon(int x, int y, int idx, int sc, uint16_t c) {
  if (idx < 0 || idx >= IC_COUNT) return;
  uint16_t hi = lerpc(c, T.white, 0.35f), lo = lerpc(c, T.bg0, 0.3f);
  for (int j = 0; j < 16; j++)
    for (int i = 0; i < 16; i++)
      if (ICONS[idx][j][i] == '#') cv.fillRect(x + i * sc + sc, y + j * sc + sc, sc, sc, T.bg0);
  for (int j = 0; j < 16; j++) {
    uint16_t col = j < 6 ? hi : (j < 11 ? c : lo);
    for (int i = 0; i < 16; i++)
      if (ICONS[idx][j][i] == '#') cv.fillRect(x + i * sc, y + j * sc, sc, sc, col);
  }
}
void drawOhm(int x, int y, uint16_t c, int sc) {
  static const char* om[7] = {".###.", "#...#", "#...#", "#...#", ".#.#.", ".#.#.", "##.##"};
  for (int j = 0; j < 7; j++)
    for (int i = 0; i < 5; i++)
      if (om[j][i] == '#') {
        cv.fillRect(x + i * sc + 1, y + j * sc + 1, sc, sc, T.bg0);
        cv.fillRect(x + i * sc, y + j * sc, sc, sc, c);
      }
}

// ------------------------------------------------------------------ toast + help
static char toastMsg[48];
static uint32_t toastUntil = 0;
void toast(const char* msg, uint32_t ms) {
  strncpy(toastMsg, msg, sizeof(toastMsg) - 1);
  toastMsg[sizeof(toastMsg) - 1] = 0;
  toastUntil = millis() + ms;
}
void drawToast() {
  if (millis() > toastUntil) return;
  int w = textW(toastMsg) + 14;
  int x = 120 - w / 2;
  panel(x, 100, w, 15, T.cyan, lerpc(T.panel, T.cyan, 0.12f));
  frame(x - 1, 99, w + 2, 17, lerpc(T.bg0, T.cyan, 0.3f));
  text(x + 7, 104, toastMsg, T.white);
}
void helpOverlay(const char* title, std::initializer_list<const char*> lines) {
  cv.fillRect(8, 14, 224, 110, lerpc(T.bg0, T.panel, 0.6f));
  panel(8, 14, 224, 110, T.cyan, T.bg1);
  text(14, 18, title, T.cyan);
  // "KEY  what it does" lines; two columns when every line fits, else one column with more pages
  auto split = [](const char* l, char* k) -> const char* {
    const char* sp = strstr(l, "  ");
    if (!sp) return nullptr;
    int m = std::min<int>(sp - l, 15);
    memcpy(k, l, m); k[m] = 0;
    return sp + 2;
  };
  char k[16];
  const int rows = 10, n = lines.size();
  // key column width for each column of each page (two-column layout); a rare long key just pushes its own line
  auto colKw = [&](int first) {
    int kw = 0, i = 0;
    for (auto l : lines) { if (i >= first && i < first + rows && split(l, k) && textW(k) <= 30) kw = std::max(kw, textW(k)); i++; }
    return kw + 6;
  };
  auto descX = [&](int kw) { return std::max(kw, textW(k) + 6); };
  bool two = true;
  { int i = 0; for (auto l : lines) { int kw = colKw(i / rows * rows); const char* d = split(l, k); if ((d ? descX(kw) + textW(d) : textW(l)) > 106) two = false; i++; } }
  int per = two ? rows * 2 : rows, pages = (n + per - 1) / per;
  int page = pages > 1 ? (millis() / 6000) % pages : 0;
  if (pages > 1) {
    char b[8]; snprintf(b, sizeof(b), "%d/%d", page + 1, pages);
    text(224 - textW(b), 18, b, T.grey, 1, false);
    cv.fillRect(14, 27, (int)(212 * (millis() % 6000) / 6000), 1, T.dim);  // time left on this page
  }
  int kws[2] = {colKw(page * per), colKw(page * per + rows)};
  if (!two) { kws[0] = 0; int i = 0; for (auto l : lines) { if (i / per == page && split(l, k) && textW(k) <= 60) kws[0] = std::max(kws[0], textW(k) + 6); i++; } }
  int i = 0;
  for (auto l : lines) {
    int j = i++ - page * per;
    if (j < 0 || j >= per) continue;
    int x = 14 + (j / rows) * 112, y = 31 + (j % rows) * 9, cw = two ? 106 : 212;
    const char* d = split(l, k);
    if (d) {
      int dx = descX(kws[j / rows]);
      text(x, y, k, T.white, 1, false);
      textFit(x + dx, y, d, T.grey, cw - dx, false);
    } else textFit(x, y, l, T.purp, cw, false);
  }
}
